# Keil uVision project qqRuz.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ..\hex\qq +hex
  c flags: Optim=4 oTime=1
  c define: LPC2148
  c include: .\code\Abstract-40;.\code\bank-40\Standard\Strd0;.\code\Board;.\code\bank-40\Standard\Strd0\TimeCtl;.\code\bank-40\Standard\Strd0\MemOut;.\code\bank-40\Standard\Strd0\MemIn;.\code\bank-40\Standard\Strd0\GPOut;.\code\bank-40\Standard\Strd0\GPIn;.\code\bank-40\Standard\Strd0\BuffOut;.\code\bank-40\Standard\Strd0\BuffIn;.\code\bank-40\Standard\Strd0\WordOut;.\code\bank-40\Standard\Strd0\WordIn;.\code\bank-40\Standard\Strd0;.\code\bank-40\Standard\Strd0\Convertors;.\code\bank-40\Standard\Strd0\Ctl;.\code\Intrface
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./code/: Sttup.s main.cpp
  group Standart
    ./code/bank-40/Standard/Strd0/: LPC2148Service.cpp
    ./code/bank-40/Standard/Strd0/TimeCtl/: Metronome_lpc2148.cpp
    ./code/bank-40/Standard/Strd0/MemOut/: I2Chw.cpp I2Cout.cpp
    ./code/bank-40/Standard/Strd0/MemIn/: I2Cin.cpp
    ./code/bank-40/Standard/Strd0/GPOut/: PinOut_LPC2148.cpp
    ./code/bank-40/Standard/Strd0/GPIn/: PinIn_LPC2148.cpp
    ./code/bank-40/Standard/Strd0/BuffOut/: LPC2148_UART.cpp BuffOut.cpp
    ./code/bank-40/Standard/Strd0/BuffIn/: BuffIn.cpp
    ./code/bank-40/Standard/Strd0/WordOut/: lpc2148_SPI.cpp AD5662_1.cpp
    ./code/bank-40/Standard/Strd0/WordIn/: LTC2447.cpp AD5592.cpp
    ./code/bank-40/Standard/Strd0/Convertors/: Convertor-D.cpp
    ./code/bank-40/Standard/Strd0/Ctl/: Controller-E.cpp
  group Board
    ./code/Board/: phuC40Board.cpp
  group Interface
    ./code/Intrface/: InterfaceParticularity.h Abrvr.h Abrvr.cpp Parser-Bi40.cpp InterfaceParticularity.cpp
    ./code/bank-40/Standard/Strd0/Convertors/: Extractor.cpp
